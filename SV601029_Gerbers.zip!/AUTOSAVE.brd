# Allegro board AUTOSAVE.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
VSS on BOTTOM: 2.54,0.76 1.28,1.28 0.76,2.54 0.76,9.55 0,10.32 0,74.68 0.05,74.68 0.05,95.25 0,95.25 0,119.26 0.76,120.02 0.76,175.26 1.28,176.52 2.54,177.04 99.06,177.04 100.32,176.52 100.84,175.26 100.84,2.54 100.32,1.28 99.06,0.76 ; 21 cut-outs
VSS on BOTTOM: 24.85,146.48 24.85,143.18 28.63,143.18 28.63,146.48
VSS on BOTTOM: 51.18,94.11 51.18,92.1 52.88,92.1 52.88,94.11
VSS on BOTTOM: 33.63,77.95 33.3,77.95 33.3,77.04 34.21,77.04 34.21,77.14 40.08,77.14 40.08,76.73 42.01,76.73 42.01,78.84 42.27,78.84 42.27,85.34 41.33,85.34 41.33,86.94 42.19,86.94 42.19,87.66 38.56,87.66 38.56,85.85 34.32,85.85 34.32,87 33.63,87
VSS on BOTTOM: 46.05,119.76 46.05,118.24 46.25,118.03 46.94,118.03 47.09,118.19 47.09,118.36 47.22,118.49 48.69,118.49 48.87,118.67 48.87,119.61 48.6,119.88 46.16,119.88
VSS on BOTTOM: 79.97,172.31 79.97,170.73 79.74,170.49 75.35,170.49 74.97,170.12 74.97,167.68 74.71,167.42 69.57,167.42 69.36,167.22 69.36,166.27 69.7,165.93 85.59,165.93 85.59,172.31
VSS on BOTTOM: 37.9,74.42 37.9,72.77 37.72,72.59 37.72,70.84 37.9,70.66 40.03,70.66 40.03,74.42
VSS on GND: 2.54,0.76 1.28,1.28 0.76,2.54 0.76,9.56 0,10.32 0,119.26 0.76,120.02 0.76,175.26 1.28,176.52 2.54,177.04 99.06,177.04 100.32,176.52 100.84,175.26 100.84,2.54 100.32,1.28 99.06,0.76
VSS on POWER: 2.54,0.76 1.28,1.28 0.76,2.54 0.76,10.11 0,10.87 0,119.26 0.76,120.02 0.76,175.26 1.24,176.47 2.41,177.03 2.51,177.04 99.36,177.04 100.41,176.54 100.84,175.46 100.84,13.21 100.84,13.21 100.84,2.54 100.32,1.28 99.06,0.76 ; 1 cut-out
N15364431 on TOP: 34.06,156.79 34.06,154.99 55.65,154.99 55.65,163.98 56.13,164.47 63.5,164.47 63.5,169.42 55.88,169.42 55.12,170.18 43.56,170.18 43.05,169.67 43.05,157.35 42.49,156.79
N15364431 on BOTTOM: 63.4,170.18 43.56,170.18 43.05,169.67 43.05,165.69 44.85,163.89 62.32,163.89 63.4,164.97
N15364577 on TOP: 30.28,161.87 30.28,160.78 32.64,160.78 33.12,161.26 36.6,161.26 36.88,160.99 36.83,160.93 36.83,157.1 39.75,157.1 40.41,157.76 40.41,168.68 40.03,169.06 30.66,169.06 30.4,168.81 30.4,165.89 30.63,165.66 33.58,165.66 33.88,165.35 33.88,164.08 33.05,163.25 33.05,162.41 32.51,161.87
N15364577 on BOTTOM: 30.38,168.96 30.38,164.29 37.19,164.29 37.19,168.96
N15364743 on TOP: 24.31,164.57 24.31,162.71 26.11,162.71 26.14,162.74 26.14,163.3 26.01,163.42 25.58,163.42 25.4,163.6 25.4,164.57
N15364759 on TOP: 30.28,157.33 30.28,156.77 30.43,156.62 30.63,156.62 30.84,156.41 30.84,155.45 30.94,155.35 31.62,155.35 31.72,155.45 31.72,156.46 31.74,156.48 31.74,156.58 32,156.84 32.13,156.84 32.13,157.33
N15364919 on TOP: 16.48,160.73 16.48,157.02 16.59,156.92 18.36,156.92 18.47,157.02 18.47,160.71 18.34,160.83 16.59,160.83
N15365001 on TOP: 30.3,160.55 30.3,159.49 33.22,159.49 33.45,159.26 33.45,157.81 33.99,157.28 35.94,157.28 36.32,157.66 36.32,159.84 36.09,160.07 34.14,160.07 33.66,160.55
N16849951 on TOP: 7.65,144.73 7.65,143.84 12.23,143.84 13.43,145.04 13.43,146.13 13.06,146.51 11.51,146.51 11.3,146.3 11.3,145.11 10.92,144.73
N16849951 on BOTTOM: 9.77,147.22 9.77,143 13.79,143 13.79,147.22
N16849991 on TOP: 2.01,147.98 2.01,145.36 10.34,145.36 10.34,150.09 10.19,150.24 8.1,150.24 7.9,150.04 7.9,147.98
N17084564 on BOTTOM: 93.04,120.17 98.4,120.17 98.73,120.5 98.73,121.21 97.71,122.22 96.42,122.22 95.4,121.21 93.14,121.21 92.99,121.06 92.99,120.22
N17084583 on BOTTOM: 93.01,119.18 93.01,118.21 93.09,118.14 95.71,118.14 96.04,117.81 98.04,117.81 98.37,118.14 98.37,119.25 98.04,119.58 95.58,119.58 95.25,119.25 93.09,119.25
N17084590 on BOTTOM: 93.04,124.51 93.04,123.04 97.94,123.04 98.22,123.32 98.22,124.51 97.97,124.76 95.94,124.76 95.68,124.51
N17132631 on TOP: 28.77,147.17 28.77,146.02 31.72,146.02 31.72,146.65 30.71,146.65 30.71,148.23 31.73,148.23 31.73,151.15 30.02,151.15 30.02,147.17
N17132631 on BOTTOM: 30.08,148.71 30.08,146.17 30.92,146.17 30.92,148.71
N17133657 on TOP: 33.78,146.69 33.78,143.56 38.07,143.56 38.07,147.27 37.95,147.4 37.95,148.56 37.74,148.77 36.93,148.77 36.7,148.54 36.7,147.4 35.99,146.69
N17179271 on TOP: 76.81,176.8 76.81,171.75 76.88,171.69 77.74,171.69 78.55,172.5 79.75,172.5 79.88,172.37 79.88,171.25 79.93,171.2 80.86,171.2 80.92,171.26 80.92,172.64 80.02,173.55 80.02,176.8
N17182034 on TOP: 74.63,167.96 74.63,169.52 74.78,169.67 74.78,170.41 74.73,170.46 73.82,170.46 72.8,169.44 71.53,169.44 71.53,168.25 71.82,167.96
N17182034 on BOTTOM: 72.31,170 72.31,167.89 74.65,167.89 74.65,170 74.37,170.28 72.59,170.28
N17214938 on TOP: 72.09,149.5 72.09,148.56 74.55,148.56 74.7,148.41 76,148.41 76.4,148.01 80.14,148.01 80.39,148.26 80.39,151.26 79.88,151.77 76.86,151.77 76.81,151.71 76.81,150.27 76.53,149.99 74.78,149.99 74.3,149.5
N17214967 on TOP: 72.09,153.42 72.09,152.45 80.44,152.45 80.77,152.78 80.77,154.94 80.57,155.14 76.68,155.14 76.25,154.71 76.25,154.53 76.17,154.46 75.03,154.46 74.9,154.33 74.9,153.54 74.78,153.42
N17214967 on TOP: 73.94,158.67 73.94,157.33 75.74,157.33 75.74,158.67
N17214967 on BOTTOM: 76.33,154.31 76.33,152.45 80.44,152.45 80.77,152.78 80.77,154.94 80.44,155.27 80.44,157.63 78.87,159.21 74.12,159.21 73.69,158.78 73.69,157.58 74.02,157.25 76.63,157.25 77.57,156.31 77.57,154.53 77.44,154.41 76.43,154.41
N17221888 on BOTTOM: 73.66,155.57 73.66,153.67 73.79,153.54 76.07,153.54 76.07,155.7 75.95,155.83 73.91,155.83

Small or netless copper shapes (teardrops, artwork): 6 on TOP, 9 on BOTTOM

## Text on the board
BOTTOM: 04_BOTTOM | UL94V-0 | MADE IN U.S.
Ref Des/Assembly Bottom: BOTTOM_ASSEMBLY
Board Geometry/Soldermask Bottom: BOTTOM-MASK | UL94V-0 | MADE IN U.S.
Package Geometry/Pastemask Bottom: BOTTOM-PASTE
Ref Des/Silkscreen Bottom: D2- | D1- | D3- | CK- | D0- | CSI1 | CSI0 | D3+ | DO+ | D2+ | D1+ | CK+ | D0+ | RIN1+ | RIN0+ | RIN1- | RIN0- | CMLOUT- | CMLOUT+ | FOR EVALUATION ONLY; NOT FCC APPROVED FOR RESALE | 305-PD-14-0700 | OCT 2014 | BOTTOM-SILK | DS90UH940-Q1EVM | DS90UB948-Q1EVM | DS90UH948-Q1EVM | DS90UB940-Q1EVM
TOP: 01_TOP | C | 2014 TI
Ref Des/Assembly Top: TOP_ASSEMBLY
Board Geometry/Soldermask Top: TOP-MASK | C | 2014 TI
Package Geometry/Pastemask Top: TOP-PASTE
Ref Des/Silkscreen Top: D6+ | CK+ | D7+ | D5+ | D4+ | D0+ | D2+ | D3+ | D1+ | D7- | D6- | D5- | CK- | D4- | D2- | D3- | D1- | D0- | RIN1+ | RIN0+ | RIN0- | CMLOUT+ | RIN1- | CMLOUT- | RIN0+/- | RIN1+/- | TDO | TDI | TMS | TCK | VSS | RST | NC | PASS | LOCK | JTAG | VDDIO | MODE_SEL1 | USB2ANY CONNECTOR | VDD33_UC | MODE_SEL0 | IDX | VDD33 | VDD18 | VDD_I2C | VDD12 | I2C_SDA | I2C_SCL | PDB | TEST | SDOUT/GPIO0 | TEST1 | SWC/GPIO1 | I2S_DC/GPIO2 | I2S_DD/GPIO3 | I2S_DB/GPIO5_REG | I2S_DA/GPIO6_REG | I2S_WC/GPIO7_REG | I2S_CLK/GPIO8_REG | MCLK | 58 | 5C | 60 | P8.0 | 64 | 68 | BISTEN | 6C | 70 | BISTC | 78 | D_GPIO3/SS | D_GPIO2/SPLK | D_GPIO1/MISO | D_GPIO0/MOSI | INTB | +12V | +5V | TOP SILK | SV601029- | REV.B
GND: 02_GND
POWER: 03_POWER
User.6: LAYER 2 | LAYER 1 | LAYER 3 | LAYER 4 | 1.4 MIL | 4.5 MIL | 1.58 MIL | 44.2 MIL | GND | TOP | POWER | BOTTOM | THIS IS A 4 LAYER BOARD | LAYER STACK-UP
User.8: FAB | COMPANY: | Santa Clara CA 95054 | 3000 Patrick Henry Drive | Fax-408-747-1239 | Direct-408-329-5500 | SIZE | SCALE | TITLE: | FSCM NO | DWG NO | SHEET | DS90Ux948_940-Q1 EVM REV-2 BOARD | 305-PD-14-0700
User.9: FIGURE | SIZE | 10.0 | 13.0 | 33.0 | 35.43 | 40.0 | 62.99 | 64.96 | 156.0 | 121.0x42.0 | 140.0x42.0 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | TOLERANCE | +3.0/-10.0 | +3.0/-3.0 | +2.0/-2.0 | +2.0/-0.0 | PLATED | NON-PLATED | QTY | 1543 | 25 | 6 | 4 | 162 | 8 | 2 | 1
User.10: LAYER: | DATE:OCT 2014 | NAME:DS90Ux948_940-Q1 EVM BRD | TEXAS AND INSTRUMENTS | JOB:305-PD-14-0700 | Rev.2
